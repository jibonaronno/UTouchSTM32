# Keil uVision project timuartidsco.uvprojx, settings and files
target timuartF4disco (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timuartidsco
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: HAL_SPI_MODULE_ENABLED,HAL_SD_MODULE_ENABLED
  c misc: --C99
  c include: C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.7.0\Drivers\STM32F4xx_HAL_Driver\Inc;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.7.0\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.7.0\Drivers\CMSIS\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.7.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Inc;.\Inc\STM32_LIBRARIES\fatfs;.\Inc\STM32_LIBRARIES\fatfs\option;.\Inc\STM32_LIBRARIES\fatfs\drivers;.\Inc\STM32_LIBRARIES
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ./Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ./Inc/STM32_LIBRARIES/: tm_stm32_fatfs.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_gpio.c tm_stm32_dma.c tm_stm32_spi.c tm_stm32_spi_dma.c
    ./Inc/STM32_LIBRARIES/fatfs/: diskio.c ff.c
    ./Inc/STM32_LIBRARIES/fatfs/drivers/: fatfs_sd.c fatfs_sd_sdio.c
    ./Inc/STM32_LIBRARIES/fatfs/option/: syscall.c unicode.c
    ./: touchDriver.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.7.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c
    C:/Keil_v5/ARM/Pack/Keil/STM32F4xx_DFP/2.7.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c
software components: CMSIS:CORE 4.3.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:Startup 2.4.2
